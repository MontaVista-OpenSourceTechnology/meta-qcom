PLATFORM = "talos"
PBT_BUILD_DATE = "260502"

require common.inc

SRC_URI[camxlib.sha256sum]     = "6e1c7895f93c812a55416601415f9c5a255ef7dd62bbefc6587fab905b9aa9d1"
SRC_URI[camx.sha256sum]        = "cd4b4408b904b633d9d3220887abac5f2bde9556553531de57e622b177d661b9"
SRC_URI[chicdk.sha256sum]      = "dfc7b4e4baa556720c47b162d392a9662ec929400101c643d3a35dad4408d256"
SRC_URI[camxcommon.sha256sum]  = "a6071ab6907fb29e469391aa23e3629a73d407d59513d18cb00c60c1d871f497"
